# Keil uVision project Temp.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: Temp +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\CMSIS\Include;..\Drives;..\mhscpu\Include;..\USER;..\MHSCPU_Driver\inc;..\Drives
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group USER
    ./: main.c
  group Drivers
    ../Drives/: delay.c
  group Core
    ../mhscpu/Source/: system_mhscpu.c startup_mhscpu.s
  group MHSCPU_Driver
    ../MHSCPU_Driver/src/: mhscpu_dma.c mhscpu_exti.c mhscpu_gpio.c mhscpu_it.c mhscpu_sysctrl.c mhscpu_uart.c misc.c mhscpu_timer.c mhscpu_trng.c
