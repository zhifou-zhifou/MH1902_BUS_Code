# Keil uVision project MH1902.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMSC300 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("SC300") CLOCK(12000000) ESEL ELITTLE
  output: MH1902 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT,ARM_MATH_CM3
  c misc: --enum_is_int
  c include: ..\Libraries\Device\MegaHunt\mhscpu\Include;..\Libraries\MHSCPU_Driver\inc;..\Libraries\Device\MegaHunt\mhscpu\Include;..\Libraries\CMSIS\Include;..\User;..\User\1608c;..\User\Protocol;..\User\delay;..\User\uart;..\User\time;..\Libraries\MHSCPU_Driver\inc\emvlib;..\User\7816;..\User\PSAM;..\User\ContactlessCard;..\User\Algorithm\crc;..\User\flash;..\User\debug;..\User\AT24Cxx;..\User\Ymodem;..\User\RTC;..\User\Digital;..\User\key;..\User\LED
  library: MicroLIB
  memory RVCT4: ROM 0x1001000 size 0xf000
  memory RVCT9: RAM 0x20000000 size 0xf000
  group MDK_ARM
    ../Libraries/Device/MegaHunt/mhscpu/Source/ARM/: startup_mhscpu.s
  group CMSIS
    ../Libraries/Device/MegaHunt/mhscpu/Source/: system_mhscpu.c
  group MHSCPU_Drive
    ../Libraries/MHSCPU_Driver/src/: mhscpu_gpio.c mhscpu_spi.c mhscpu_sysctrl.c misc.c mhscpu_uart.c mhscpu_timer.c mhscpu_emv_hard.c mhscpu_flash.c mhscpu_rtc.c mhscpu_bpk.c mhscpu_sensor.c
  group Flash
    ../User/flash/: flash.c
  group USER
    ../User/: gpio.c main.c mhscpu_it.c spi.c
    ../User/delay/: delay.c
    ../User/uart/: uart.c
    ../User/time/: timer.c
    ../User/7816/: 7816.c
    ../User/debug/: debug.c
    ../User/Digital/: Digital.c
    ../User/key/: key.c multi_button.c example_poll.c
    ../User/LED/: led.c
  group 1608C
    ../User/1608c/: iso14443_4.c iso14443a.c iso14443b.c mh523.c mifare.c ContactlessAPI.c
  group PSAM
    ../User/PSAM/: psam.c psam_bsp.c psamAPI.c
  group Algorithm
    ../User/Algorithm/crc/: crc.c
  group PROTOCOL
    ../User/Protocol/: Packet.c JRreader.c
  group EMVlib
    ../Libraries/MHSCPU_Driver/lib/: mh1902_emv.lib
  group E2PROM
    ../User/AT24Cxx/: 24cxx.c
  group Ymodem
    ../User/Ymodem/: Download.c Iap_Flash.c Ymodem.c
  group RTC
    ../User/RTC/: rtc.c bpk.c
